IMAGE_INSTALL += " helloworld"

